# Keil uVision project copter_emb_f4.uvproj, settings and files
target copter_emb_f4 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: copter_emb_f4
  c flags: Optim=1 wLevel=2
  c include: .\source\CMSIS;.\source\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./source/CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group startup
    ./source/startup/: startup_stm32f4xx.s
  group include
    ./source/include/: Buffer.h ClockControl.h I2C.h Messenger.h MPU6050.h Serial.h Timer.h USART.h Wire.h
  group source
    ./source/source/: Buffer.c ClockControl.c I2C.c main.c Messenger.c MPU6050.c Serial.c Timer.c USART.c Wire.c
